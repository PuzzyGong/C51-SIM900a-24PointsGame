# Keil uVision project keshe.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: keshe +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c deal.c deal.h
  group 24points
    ./: 24points.c 24points.h
  group hardware
    ./: infrared.c infrared.h lcd.c lcd.h uart.c uart.h
